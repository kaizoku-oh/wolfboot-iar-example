# IAR project application.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Full.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: USE_HAL_DRIVER; STM32F401xE; WOLFBOOT_FIXED_PARTITIONS; PLATFORM_stm32f4; ARCH_ARM; WOLFSSL_USER_SETTINGS; DEBUG_CONSOLE_ASSERT_DISABLE=1; WOLFBOOT_SIGN_ECC256; WOLFBOOT_HASH_SHA256; WOLFSSL_SP_ASM; WOLFSSL_SP_ARM_CORTEX_M_ASM
  ICCARM.CCIncludePath2: ../bootloader; ../../src/bootloader/include; ../../src/application/Core/Inc; ../../src/application/Drivers/STM32F4xx_HAL_Driver/Inc; ../../src/application/Drivers/STM32F4xx_HAL_Driver/Inc/Legacy; ../../src/application/Drivers/CMSIS/Device/ST/STM32F4xx/Include; ../../src/application/Drivers/CMSIS/Include
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: application.bin
  ILINK.IlinkOutputFile: application.out
  ILINK.IlinkExtraOptions: --redirect __write=__custom_write
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  ICCARM.CCDefines: NDEBUG; USE_HAL_DRIVER; STM32F401xE; WOLFBOOT_FIXED_PARTITIONS; PLATFORM_stm32f4; ARCH_ARM; WOLFSSL_USER_SETTINGS; DEBUG_CONSOLE_ASSERT_DISABLE=1; WOLFBOOT_SIGN_ECC256; WOLFBOOT_HASH_SHA256; WOLFSSL_SP_ASM; WOLFSSL_SP_ARM_CORTEX_M_ASM
  ICCARM.CCOptLevel: 3
  group Application/EWARM
    ./: startup_stm32f401xe.s
  group Application/User/Core
    ../../src/application/Core/Src/: main.c stm32f4xx_hal_msp.c stm32f4xx_it.c
  group Drivers/CMSIS
    ../../src/application/Core/Src/: system_stm32f4xx.c
  group Drivers/STM32F4xx_HAL_Driver
    ../../src/application/Drivers/STM32F4xx_HAL_Driver/Src/: stm32f4xx_hal.c stm32f4xx_hal_cortex.c stm32f4xx_hal_dma.c stm32f4xx_hal_dma_ex.c stm32f4xx_hal_exti.c stm32f4xx_hal_flash.c stm32f4xx_hal_flash_ex.c stm32f4xx_hal_flash_ramfunc.c stm32f4xx_hal_gpio.c stm32f4xx_hal_pwr.c stm32f4xx_hal_pwr_ex.c stm32f4xx_hal_rcc.c stm32f4xx_hal_rcc_ex.c stm32f4xx_hal_tim.c stm32f4xx_hal_tim_ex.c stm32f4xx_hal_uart.c
  group WolfBoot
    ../../src/bootloader/src/: libwolfboot.c
    ../../src/bootloader/hal/: stm32f4.c
