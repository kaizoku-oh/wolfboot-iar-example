<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\application\application.ewp</path>
    </project>
    <project>
        <path>$WS_DIR$\bootloader\bootloader.ewp</path>
    </project>
    <batchBuild />
</workspace>
