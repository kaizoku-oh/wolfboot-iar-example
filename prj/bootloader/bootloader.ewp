# IAR project bootloader.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: STM32F401RE ST STM32F401RE
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 39
  General.FPU2: 4
  ICCARM.CCDefines: __WOLFBOOT; PLATFORM_stm32f4; ARCH_ARM; WOLFSSL_USER_SETTINGS; DEBUG_CONSOLE_ASSERT_DISABLE=1; WOLFBOOT_SIGN_ECC256; WOLFBOOT_HASH_SHA256; WOLFSSL_SP_ASM; WOLFSSL_SP_ARM_CORTEX_M_ASM; ARCH_FLASH_OFFSET=0x08000000; WOLFBOOT_FIXED_PARTITIONS; IMAGE_HEADER_SIZE=0x200
  ICCARM.CCIncludePath2: ../../src/common; ../../src/bootloader; ../../src/bootloader/include; ../../src/bootloader/lib/wolfssl
  ICCARM.CCOptLevel: 0
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: bootloader.bin
  ILINK.IlinkOutputFile: bootloader.out
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.OGChipSelectEditMenu: Default None
  General.CoreVariant: 38
  General.FPU2: 0
  ICCARM.CCDefines: NDEBUG; __WOLFBOOT; PLATFORM_stm32f4; ARCH_ARM; WOLFSSL_USER_SETTINGS; DEBUG_CONSOLE_ASSERT_DISABLE=1; WOLFBOOT_SIGN_ECC256; WOLFBOOT_HASH_SHA256; WOLFSSL_SP_ASM; WOLFSSL_SP_ARM_CORTEX_M_ASM; ARCH_FLASH_OFFSET=0x08000000; WOLFBOOT_FIXED_PARTITIONS
  ICCARM.CCOptLevel: 3
  group hal
    ../../src/bootloader/hal/: stm32f4.c
  group hal/spi
    ../../src/bootloader/hal/spi/: spi_drv_stm32.c
  group lib/wolfssl/wolfcrypt
    ../../src/bootloader/lib/wolfssl/wolfcrypt/src/: ecc.c hash.c memory.c sha.c sha256.c sp_cortexm.c sp_int.c wc_port.c
  group src
    ../../src/bootloader/src/: boot_arm.c image.c keystore.c libwolfboot.c loader.c string.c update_flash.c
